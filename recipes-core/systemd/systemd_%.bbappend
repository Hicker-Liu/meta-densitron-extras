FILES_${PN} += " \
        ${datadir}/bash-completion/completions/bootctl \
        ${datadir}/bash-completion/completions/busctl \
        ${datadir}/bash-completion/completions/coredumpctl \
        ${datadir}/bash-completion/completions/hostnamectl \
        ${datadir}/bash-completion/completions/journalctl \
        ${datadir}/bash-completion/completions/kernel-install \
        ${datadir}/bash-completion/completions/localectl \
        ${datadir}/bash-completion/completions/loginctl \
        ${datadir}/bash-completion/completions/machinectl \
        ${datadir}/bash-completion/completions/systemctl \
        ${datadir}/bash-completion/completions/systemd-* \
        ${datadir}/bash-completion/completions/timedatectl \
"
