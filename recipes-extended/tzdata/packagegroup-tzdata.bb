inherit packagegroup 

RDEPENDS_${PN} = " \
    tzdata \
    tzdata-americas \
    tzdata-antarctica \
    tzdata-arctic \
    tzdata-asia \
    tzdata-atlantic \
    tzdata-australia \
    tzdata-europe \
    tzdata-pacific \
    tzdata-posix \
    tzdata-right \
    tzdata-misc \ 
"
