QT5_IMAGE_INSTALL_common_remove = "nxp-demo-experience"
